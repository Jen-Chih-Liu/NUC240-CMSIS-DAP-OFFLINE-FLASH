# Keil uVision project CMSIS_DAP_FLASH.uvproj, settings and files
target CMSIS_DAP_FLASH (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: NUC240VE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: CMSIS_DAP_FLASH
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST
  c misc: --c99
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC230_240\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\DAP;..\..\CMSIS_DAP_FLASH
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC230_240.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/ARM/: startup_NUC230_240.s
  group User
    ../: main.c error.c SWD_flash.c SWD_host.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c gpio.c uart.c clk.c sys.c
  group New Group
    ../DAP/: DAP.c JTAG_DP.c SW_DP.c SWO.c
